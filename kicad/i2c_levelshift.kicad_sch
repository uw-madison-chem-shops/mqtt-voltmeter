File: kicad/i2c_levelshift.kicad_sch (KiCad schematic)
At the start: 6 parts, among them Q3 2N7000

Commit message: firmware update
Parts:
- renumbered Q3 to Q4, R10 to R12, R11 to R13
